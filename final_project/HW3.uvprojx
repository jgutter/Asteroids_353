# Keil uVision project HW3.uvprojx, settings and files
target HW2 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include;..\drivers\include;..\peripherals\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c main.h vector.h vector.c ship.c asteroid.h Object.h asteroid.c game.h bullet.h bullet.c game.c ece353_hw2_fonts.c ece353_hw2_fonts.h
  group drivers
    ../drivers/c/: adc.c gpio_port.c timers.c spi.c i2c.c
    ../drivers/include/: spi.h i2c.h
  group peripherals
    ../peripherals/c/: launchpad_io.c lcd.c ps2.c ft6x06.c wireless.c eeprom.c
    ../peripherals/include/: ft6x06.h wireless.h eeprom.h
  group lib
    ../lib/: ECE353-Validate.lib
  group ::Device
    RTE/Device/TM4C123GH6PM/: startup_TM4C123.s system_TM4C123.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
